<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\development\IAR\GuruxDLMS.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\GuruxDLMSServerExample.ewp</path>
    </project>
    <batchBuild />
</workspace>
