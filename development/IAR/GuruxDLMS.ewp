# IAR project GuruxDLMS.ewp, settings and files
configuration Library (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: _LIB
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\src\lib\dlib\runtime\; $TOOLKIT_DIR$\src\lib\dlib\; $TOOLKIT_DIR$\src\lib\; D:\Users\User\Documents\Gurux.DLMS.cpp\development\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: GuruxDLMS.out
  group (top)
    ./: Readme.txt
  group inc
    ../include/: chipperingenums.h enums.h errorcodes.h GXAPDU.h GXApplicationContextName.h GXAttributeCollection.h GXAuthentication.h GXAuthenticationMechanismName.h GXBytebuffer.h GXCipher.h GXDataInfo.h GXDate.h GXDateTime.h GXDLMS.h GXDLMSActionItem.h GXDLMSActionSchedule.h GXDLMSActionSet.h GXDLMSActivityCalendar.h GXDLMSAssociationLogicalName.h GXDLMSAssociationShortName.h GXDLMSAttribute.h GXDLMSAutoAnswer.h GXDLMSAutoConnect.h GXDLMSCaptureObject.h GXDLMSClient.h GXDLMSClock.h GXDLMSConnectionEventArgs.h GXDLMSContextType.h GXDLMSConverter.h GXDLMSData.h GXDLMSDayProfile.h GXDLMSDayProfileAction.h GXDLMSDemandRegister.h GXDLMSDisconnectControl.h GXDLMSEmergencyProfile.h GXDLMSExtendedRegister.h GXDLMSGPRSSetup.h GXDLMSHdlcSetup.h GXDLMSIECOpticalPortSetup.h GXDLMSImageActivateInfo.h GXDLMSImageTransfer.h GXDLMSIp4Setup.h GXDLMSIp4SetupIpOption.h GXDLMSLimiter.h GXDLMSLimits.h GXDLMSLNParameters.h GXDLMSLongTransaction.h GXDLMSMacAddressSetup.h GXDLMSMBusClient.h GXDLMSMBusMasterPortSetup.h GXDLMSMBusSlavePortSetup.h GXDLMSMessageHandler.h GXDLMSModemConfiguration.h GXDLMSModemInitialisation.h GXDLMSMonitoredValue.h GXDLMSNotify.h GXDLMSObject.h GXDLMSObjectCollection.h GXDLMSObjectDefinition.h GXDLMSObjectFactory.h GXDLMSPppSetup.h GXDLMSPppSetupIPCPOption.h GXDLMSPppSetupLcpOption.h GXDLMSProfileGeneric.h GXDLMSPushObject.h GXDLMSPushSetup.h GXDLMSQualityOfService.h GXDLMSRegister.h GXDLMSRegisterActivation.h GXDLMSRegisterMonitor.h GXDLMSSapAssignment.h GXDLMSSchedule.h GXDLMSScheduleEntry.h GXDLMSScript.h GXDLMSScriptAction.h GXDLMSScriptTable.h GXDLMSSeasonProfile.h GXDLMSSecureClient.h GXDLMSSecureServer.h GXDLMSSecuritySetup.h GXDLMSServer.h GXDLMSSettings.h GXDLMSSNParameters.h GXDLMSSpecialDay.h GXDLMSSpecialDaysTable.h GXDLMSTcpUdpSetup.h GXDLMSValueEventArg.h GXDLMSValueEventCollection.h GXDLMSVariant.h GXDLMSWeekProfile.h GXHelpers.h GXReplyData.h GXSecure.h GXSerialNumberCounter.h GXSNInfo.h GXStandardObisCode.h GXStandardObisCodeCollection.h GXTime.h IGXDLMSBase.h OBiscodes.h
  group src
    ../src/: GXAPDU.cpp GXApplicationContextName.cpp GXAuthenticationMechanismName.cpp GXBytebuffer.cpp GXCipher.cpp GXDateTime.cpp GXDLMS.cpp GXDLMSActionItem.cpp GXDLMSActionSchedule.cpp GXDLMSActionSet.cpp GXDLMSActivityCalendar.cpp GXDLMSAssociationLogicalName.cpp GXDLMSAssociationShortName.cpp GXDLMSAutoAnswer.cpp GXDLMSAutoConnect.cpp GXDLMSCaptureObject.cpp GXDLMSClient.cpp GXDLMSClock.cpp GXDLMSContextType.cpp GXDLMSConverter.cpp GXDLMSData.cpp GXDLMSDayProfile.cpp GXDLMSDayProfileAction.cpp GXDLMSDemandRegister.cpp GXDLMSDisconnectControl.cpp GXDLMSEmergencyProfile.cpp GXDLMSExtendedRegister.cpp GXDLMSGPRSSetup.cpp GXDLMSHdlcSetup.cpp GXDLMSIECOpticalPortSetup.cpp GXDLMSImageActivateInfo.cpp GXDLMSImageTransfer.cpp GXDLMSIp4Setup.cpp GXDLMSIp4SetupIpOption.cpp GXDLMSLimiter.cpp GXDLMSLimits.cpp GXDLMSLNParameters.cpp GXDLMSMacAddressSetup.cpp GXDLMSMBusClient.cpp GXDLMSMBusMasterPortSetup.cpp GXDLMSMBusSlavePortSetup.cpp GXDLMSMessageHandler.cpp GXDLMSModemConfiguration.cpp GXDLMSModemInitialisation.cpp GXDLMSMonitoredValue.cpp GXDLMSNotify.cpp GXDLMSObject.cpp GXDLMSObjectCollection.cpp GXDLMSObjectDefinition.cpp GXDLMSObjectFactory.cpp GXDLMSPppSetup.cpp GXDLMSPppSetupIPCPOption.cpp GXDLMSPppSetupLcpOption.cpp GXDLMSProfileGeneric.cpp GXDLMSPushObject.cpp GXDLMSPushSetup.cpp GXDLMSQualityOfService.cpp GXDLMSRegister.cpp GXDLMSRegisterActivation.cpp GXDLMSRegisterMonitor.cpp GXDLMSSapAssignment.cpp GXDLMSSchedule.cpp GXDLMSScheduleEntry.cpp GXDLMSScript.cpp GXDLMSScriptAction.cpp GXDLMSScriptTable.cpp GXDLMSSeasonProfile.cpp GXDLMSSecureClient.cpp GXDLMSSecureServer.cpp GXDLMSSecuritySetup.cpp GXDLMSServer.cpp GXDLMSSettings.cpp GXDLMSSNParameters.cpp GXDLMSSpecialDay.cpp GXDLMSSpecialDaysTable.cpp GXDLMSTcpUdpSetup.cpp GXDLMSValueEventArg.cpp GXDLMSVariant.cpp GXDLMSWeekProfile.cpp GXHelpers.cpp GXReplyData.cpp GXSecure.cpp GXSerialNumberCounter.cpp GXSNInfo.cpp GXStandardObisCode.cpp GXStandardObisCodeCollection.cpp
